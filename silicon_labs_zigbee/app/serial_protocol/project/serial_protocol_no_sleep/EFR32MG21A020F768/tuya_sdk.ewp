# IAR project tuya_sdk.ewp, settings and files
configuration Normal (ARM, debug)
  General.OGChipSelectEditMenu: EFR32MG21A020F768IM32 SiliconLaboratories EFR32MG21A020F768IM32
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros; --separate_cluster_for_initialized_variables
  ICCARM.CCIncludePath2: $FILE_DIR$; ..\; ..\..\..\..\..\include; ..\include; ..\..\..\common\include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $FILE_DIR$; $PROJ_DIR$; ..\..\..; ..\..\..\protocol\zigbee\app\framework; ..\..\..\protocol\zigbee\app\framework\..\..; ..\..\..\protocol\zigbee\app\framework\..\..\stack; ..\..\..\protocol\zigbee\app\framework\..\util; ..\..\..\protocol\zigbee\app\framework\include; ..\..\..\platform\base\hal; ..\..\..\platform\base\hal\plugin; ..\..\..\platform\base\hal\..; ..\..\..\platform\base\hal\micro\cortexm3\efm32; ..\..\..\platform\base\hal\micro\cortexm3\efm32\config; ..\..\..\platform\base\hal\micro\cortexm3\efm32\efr32; ..\..\..\platform\base\hal\..\..\CMSIS\Include; ..\..\..\platform\base\hal\..\..\Device\SiliconLabs\efr32mg13p\Include; ..\..\..\platform\base\hal\..\..\emdrv\common\inc; ..\..\..\platform\base\hal\..\..\emdrv\config; ..\..\..\platform\base\hal\..\..\emdrv\dmadrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\gpiointerrupt\inc; ..\..\..\platform\base\hal\..\..\emdrv\rtcdrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\rtcdrv\test; ..\..\..\platform\base\hal\..\..\emdrv\sleep\inc; ..\..\..\platform\base\hal\..\..\emdrv\spidrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\tempdrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\uartdrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\ustimer\inc; ..\..\..\platform\base\hal\..\..\emlib\inc; ..\..\..\platform\base\hal\..\..\middleware\glib; ..\..\..\platform\base\hal\..\..\middleware\glib\glib; ..\..\..\platform\base\hal\..\..\radio\rail_lib\chip\efr32\rf\common\cortex; ..\..\..\platform\base\hal\..\..\radio\rail_lib\chip\efr32\rf\rfprotocol\ieee802154\cortex; ..\..\..\platform\halconfig\inc\hal-config; ..\..\..\hardware\kit\common\halconfig; ..\..\..\hardware\kit\common\bsp; hal-config; ..\..\..\platform\bootloader; ..\..\..\platform\radio\rail_lib\chip\efr32\efr32xg1x; ..\..\..\platform\radio\rail_lib\protocol\zwave; ..\..\..\platform\radio\rail_lib\protocol\ieee802154; ..\..\..\platform\radio\rail_lib\protocol\ble; ..\..\..\platform\radio\rail_lib\common; ..\..\..\platform\radio\rail_lib\plugin\coexistence\hal\efr32; ..\..\..\platform\radio\rail_lib\plugin\coexistence\common; ..\..\..\platform\radio\rail_lib\plugin\coexistence\protocol\ieee802154
  OBJCOPY.OOCOutputFile: tuya_sdk.s37
  prebuild: ..\..\..\..\..\tools\iar_tools\sdk_route-prebuild.bat '$TARGET_BPATH$' '$PROJ_DIR$' '$TOOLKIT_DIR$' '$PROJ_DIR$' '$TARGET_DIR$' 'EFR32MG21A020F768'
  postbuild: ..\..\..\..\..\tools\iar_tools\sdk_route-postbuild.bat '$TARGET_BPATH$' '$PROJ_DIR$' '$TOOLKIT_DIR$' '$PROJ_DIR$' '$TARGET_DIR$' 'EFR32MG21A020F768'
  ILINK.IlinkOutputFile: sdk_route.out
  ILINK.IlinkConfigDefines: FLASH_SIZE=786432; RAM_SIZE=65536; SIMEEPROM_SIZE=32768; LOCKBITS_IN_MAINFLASH_SIZE=8192; APP_BTL=1; EMBER_MALLOC_HEAP_SIZE=10240
  ILINK.IlinkIcfFile: ..\..\..\..\..\tools\iar_tools\icf\main_icf\iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group include
    ../../../common/include/: cJSON.h cJSON_Utils.h jsmn.h mcu_api.h serial_protocol.h serial_protocol_queue.h system.h
    ../include/: config.h serial_protocol_callbacks.h
    ../../../../../include/: hal_battery.h mf_test_callback.h type_def.h zcl_command_micro.h zigbee_attr.h zigbee_cmd.h zigbee_dev_template.h zigbee_modules.h zigbee_sdk.h
  group Libraries
    ../../../../../lib/iar_lib/EFR32MG21A020F768/: binding-table-library.a cbke-163k1-stub-library.a cbke-283k1-stub-library.a cbke-library-dsa-sign-stub.a cbke-library-dsa-verify-283k1-stub.a cbke-library-dsa-verify-stub.a cbke-stub-library.a debug-basic-library.a debug-basic-stub-library.a debug-extended-stub-library.a end-device-bind-stub-library.a gp-library.a gp-stub-library.a hal-library.a install-code-library.a libnvm3_CM33_iar.a librail_efr32xg21_iar_release.a mfglib-library.a multi-network-stub-library.a packet-validate-library.a packet-validate-stub-library.a security-library-core.a security-library-link-keys-stub.a sim-eeprom2-to-nvm3-upgrade-stub-library.a tuya_sdk.a zigbee-pro-leaf-stack.a zigbee-pro-stack.a zigbee-r22-support-stub-library.a zll-stub-library.a
  group src
    ../src/: config.c no_sleep_process.c oem_util.c si32_zg_uart_connect_no_sleep_ty_callback.c
    ../../../common/src/: mcu_api.c serial_protocol.c serial_protocol_queue.c system.c
