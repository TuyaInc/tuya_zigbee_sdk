# IAR project tuya_sdk.ewp, settings and files
configuration Normal (ARM, debug)
  General.OGChipSelectEditMenu: EFR32MG13P732F512GM48 SiliconLaboratories EFR32MG13P732F512GM48
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: APP_DEBUG; xSLEEP_END_DEVICE_POLL_ALWAYS
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros; --separate_cluster_for_initialized_variables
  ICCARM.CCIncludePath2: $FILE_DIR$; $PROJ_DIR$; ..\..\..\..\..\include; ..\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: APP_GECKO_INFO_PAGE_BTL; CORTEXM3; CORTEXM3_EFM32_MICRO; CORTEXM3_EFR32_MICRO; CORTEXM3_EFR32; EFR32_SERIES1_CONFIG3_MICRO; EFR32MG13P; EFR32MG13P732F512GM48; HAL_CONFIG=1; EMBER_AF_USE_HWCONF; EMLIB_USER_CONFIG; EMBER_PARAMETERIZED_BROADCAST_TABLE; USE_SIMEE2; EMBER_STACK_ZIGBEE; PHY_RAIL=1
  AARM.AUserIncludes: $FILE_DIR$; $PROJ_DIR$; ..\..\..\..; ..\..\..\..\protocol\zigbee\app\framework; ..\..\..\..\protocol\zigbee\app\framework\..\..; ..\..\..\..\protocol\zigbee\app\framework\..\..\stack; ..\..\..\..\protocol\zigbee\app\framework\..\util; ..\..\..\..\protocol\zigbee\app\framework\include; ..\..\..\..\platform\base\hal; ..\..\..\..\platform\base\hal\plugin; ..\..\..\..\platform\base\hal\..; ..\..\..\..\platform\base\hal\micro\cortexm3\efm32; ..\..\..\..\platform\base\hal\micro\cortexm3\efm32\config; ..\..\..\..\platform\base\hal\micro\cortexm3\efm32\efr32; ..\..\..\..\platform\base\hal\..\..\CMSIS\Include; ..\..\..\..\platform\base\hal\..\..\Device\SiliconLabs\efr32mg13p\Include; ..\..\..\..\platform\base\hal\..\..\emdrv\common\inc; ..\..\..\..\platform\base\hal\..\..\emdrv\config; ..\..\..\..\platform\base\hal\..\..\emdrv\dmadrv\inc; ..\..\..\..\platform\base\hal\..\..\emdrv\gpiointerrupt\inc; ..\..\..\..\platform\base\hal\..\..\emdrv\rtcdrv\inc; ..\..\..\..\platform\base\hal\..\..\emdrv\rtcdrv\test; ..\..\..\..\platform\base\hal\..\..\emdrv\sleep\inc; ..\..\..\..\platform\base\hal\..\..\emdrv\spidrv\inc; ..\..\..\..\platform\base\hal\..\..\emdrv\tempdrv\inc; ..\..\..\..\platform\base\hal\..\..\emdrv\uartdrv\inc; ..\..\..\..\platform\base\hal\..\..\emdrv\ustimer\inc; ..\..\..\..\platform\base\hal\..\..\emlib\inc; ..\..\..\..\platform\base\hal\..\..\middleware\glib; ..\..\..\..\platform\base\hal\..\..\middleware\glib\glib; ..\..\..\..\platform\base\hal\..\..\radio\rail_lib\chip\efr32\rf\common\cortex; ..\..\..\..\platform\base\hal\..\..\radio\rail_lib\chip\efr32\rf\rfprotocol\ieee802154\cortex; ..\..\..\..\platform\halconfig\inc\hal-config; ..\..\..\..\hardware\kit\common\halconfig; ..\..\..\..\hardware\kit\common\bsp; hal-config; ..\..\..\..\platform\bootloader; ..\..\..\..\platform\radio\rail_lib\chip\efr32\efr32xg1x; ..\..\..\..\platform\radio\rail_lib\protocol\zwave; ..\..\..\..\platform\radio\rail_lib\protocol\ieee802154; ..\..\..\..\platform\radio\rail_lib\protocol\ble; ..\..\..\..\platform\radio\rail_lib\common; ..\..\..\..\platform\radio\rail_lib\plugin\coexistence\hal\efr32; ..\..\..\..\platform\radio\rail_lib\plugin\coexistence\common; ..\..\..\..\platform\radio\rail_lib\plugin\coexistence\protocol\ieee802154
  OBJCOPY.OOCOutputFile: tuya_sdk.s37
  prebuild: ..\..\..\..\..\tools\iar_tools\sdk_route-prebuild.bat '$TARGET_BPATH$' '$PROJ_DIR$' '$TOOLKIT_DIR$' '$PROJ_DIR$' '$TARGET_DIR$' EFR32MG13P732F512
  postbuild: ..\..\..\..\..\tools\iar_tools\sdk_route-postbuild.bat '$TARGET_BPATH$' '$PROJ_DIR$' '$TOOLKIT_DIR$' '$PROJ_DIR$' '$TARGET_DIR$' EFR32MG13P732F512
  ILINK.IlinkOutputFile: sdk_route.out
  ILINK.IlinkConfigDefines: FLASH_SIZE=524288; RAM_SIZE=65536; SIMEEPROM_SIZE=36864; APP_GECKO_INFO_PAGE_BTL=1; EMBER_MALLOC_HEAP_SIZE=10240
  ILINK.IlinkIcfFile: ..\..\..\..\..\tools\iar_tools\icf\main_icf\iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration debug (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: APP_DEBUG
  ICCARM.CCIncludePath2: $FILE_DIR$; $PROJ_DIR$; ..\..\..\..\..\include; include
  OBJCOPY.OOCOutputFile: sdk_route.s37
  prebuild: ..\..\..\..\..\tools\iar_tools\sdk_route-prebuild.bat '$TARGET_BPATH$' '$PROJ_DIR$' '$TOOLKIT_DIR$' '$PROJ_DIR$' '$TARGET_DIR$'
  postbuild: ..\..\..\..\..\tools\iar_tools\sdk_route-postbuild.bat '$TARGET_BPATH$' '$PROJ_DIR$' '$TOOLKIT_DIR$' '$PROJ_DIR$' '$TARGET_DIR$'
configuration 1P132_release (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: $FILE_DIR$; $PROJ_DIR$; ..\..\..\..\include
  AARM.ADefines: APP_BTL; CORTEXM3; CORTEXM3_EFR32; CORTEXM3_EFR32_MICRO; CORTEXM3_EFM32_MICRO; EFR32_SERIES1_CONFIG1_MICRO; EFR32MG1B; EFR32MG1B132F256GM48; HAL_CONFIG=1; EMBER_AF_USE_HWCONF; EMLIB_USER_CONFIG; EMBER_PARAMETERIZED_BROADCAST_TABLE; USE_SIMEE2; EMBER_STACK_ZIGBEE; PHY_RAIL=1
  OBJCOPY.OOCOutputFile: sdk_route.s37
  prebuild: ..\..\..\..\tools\iar_tools\sdk_route-prebuild.bat '$TARGET_BPATH$' '$PROJ_DIR$' '$TOOLKIT_DIR$' '$PROJ_DIR$' '$TARGET_DIR$'
  postbuild: ..\..\..\..\tools\iar_tools\sdk_route-postbuild.bat '$TARGET_BPATH$' '$PROJ_DIR$' '$TOOLKIT_DIR$' '$PROJ_DIR$' '$TARGET_DIR$'
  ILINK.IlinkConfigDefines: FLASH_SIZE=262144; RAM_SIZE=32768; SIMEEPROM_SIZE=8192; APP_BTL=1; EMBER_MALLOC_HEAP_SIZE=10240
  ILINK.IlinkIcfFile: ..\..\..\..\tools\iar_tools\icf\main_icf\iar-cfg.icf
configuration sleep_poll_always (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: APP_DEBUG; SLEEP_END_DEVICE_POLL_ALWAYS
  ICCARM.CCIncludePath2: as above
  prebuild: as above
  postbuild: as above
  group device_code
    ../src/: config.c light_control.c light_cw_demo_callback.c light_init.c light_set_color.c soc_flash.c soc_gpio.c soc_pwm.c soc_timer.c user_flash.c user_pwm.c user_timer.c
  group include
    ../../../../../include/: mf_test_callback.h type_def.h zigbee_attr.h zigbee_cmd.h zigbee_dev_template.h zigbee_sdk.h
  group Libraries
    ../../../../../lib/iar_lib/EFR32MG13P732F512/: binding-table-library.a cbke-163k1-stub-library.a cbke-283k1-stub-library.a cbke-library-dsa-sign-stub.a cbke-library-dsa-verify-283k1-stub.a cbke-library-dsa-verify-stub.a cbke-stub-library.a debug-basic-library.a debug-extended-stub-library.a end-device-bind-stub-library.a gp-library.a gp-stub-library.a hal-library.a install-code-library.a librail_efr32xg13_iar_release.a mfglib-library.a multi-network-stub-library.a packet-validate-library.a security-library-core.a security-library-link-keys-stub.a sim-eeprom2-1to2-upgrade-stub-library.a sim-eeprom2-library.a tuya_sdk.a tuya_sdk_big_user_flash.a tuya_sdk_zg30.a zigbee-pro-stack.a zigbee-r22-support-stub-library.a zll-library.a zll-stub-library.a
